# Keil uVision project Robotcar.uvprojx, settings and files
target Target 1 (6140000::V6.14::ARMCLANG)
  device: STM32F411CEUx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.14.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Robotcar
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./UserLib/: adc_dma.c adc_dma.h control.c control.h delay.c delay.h gpio.c gpio.h main.c SystemClock.c SystemClock.h tim3_pwm_dma.c tim3_pwm_dma.h uart.c uart.h
software components: CMSIS:CORE 5.6.0, Device:Startup 2.6.3
